# Keil uVision project stm32f103c8.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103c8 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: .\_user;.\_user\1CORE;.\_user\2drive\STM32F1xx_HAL_Driver\Inc;.\_user\2drive\STM32F1xx_HAL_Driver\Inc\Legacy;.\_user\3BSP;.\_user\4device;.\_user\5function;.\_user\4device\OLED\Example;.\_user\4device\OLED\OLED;.\_user\4device\OLED\Fonts;.\_user\4device\OLED;.\_user\4device\OLED\iic;.\_user\4device\AD7124;.\_user\4device\AD7124\ad7124_noos
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ./_user/1CORE/: system_stm32f1xx.c stm32f1xx_it.h stm32f1xx_it.c stm32f1xx_hal_conf.h startup_stm32f103xb.s
  group drive
    ./_user/2drive/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_i2c.c
  group BSP
    ./_user/3BSP/: bsp_gpio.c bsp_spi.c bsp_timer.c bsp_uart.c IIC.c
  group device
    ./_user/4device/: Fan.c LED.c key.c OLED.c SHT.c
  group main
    ./_user/: main.c config.c config.h boardIO.h
  group OLED_drive
    ./_user/4device/OLED/OLED/: OLED_0in91.c OLED_0in95_rgb.c OLED_0in96.c OLED_1in3.c OLED_1in3_c.c OLED_1in5.c OLED_1in5_rgb.c
    ./_user/4device/OLED/iic/: Soft_IIC.c
    ./_user/4device/OLED/: DEV_Config.c
    ./_user/5function/: GUI_Paint.c
  group OLED_examp
    ./_user/4device/OLED/Example/: ImageData.c
  group OLED_font
    ./_user/4device/OLED/Fonts/: font8.c font12.c font12CN.c font16.c font20.c font24.c font24CN.c
  group AD7124_lib1
    ./_user/4device/AD7124/: ad7124_console_app.c ad7124_regs_config_a.c ad7124_regs_config_b.c ad7124_support.c adi_console_menu.c delay.c platform_support.c spi.c
  group AD7124_lib2
    ./_user/4device/AD7124/ad7124_noos/: ad7124.c ad7124_regs.c
software components: CMSIS:CORE 5.4.0
