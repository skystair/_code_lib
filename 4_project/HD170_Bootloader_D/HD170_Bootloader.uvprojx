# Keil uVision project HD170_Bootloader.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: HC32F170JATA HDSC
  pack: HDSC.HC32F17X.1.0.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HD_bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 wLevel=4
  c include: .\_USERS;.\_USERS\Huada;.\_USERS\Huada\driver\inc;.\_USERS\BSP;.\_USERS\devices;.\_USERS\function
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --keep=*Handler
  group main
    ./_USERS/: main.c config.c config.h startup_hc32f19x.s
    ./_USERS/Huada/: system_hc32f19x.c interrupts_hc32f19x.c board_stkhc32f19x.h
  group Driver
    ./_USERS/Huada/driver/src/: ddl.c gpio.c sysctrl.c timer3.c uart.c flash.c wdt.c
  group bsp
    ./_USERS/BSP/: timer.c uartx.c mainuart.c bspflash.c
  group function
    ./_USERS/function/: jump.c MainFunc.c
software components: CMSIS:CORE 5.6.0
