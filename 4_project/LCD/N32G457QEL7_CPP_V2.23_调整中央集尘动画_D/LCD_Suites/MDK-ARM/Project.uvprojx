# Keil uVision project Project.uvprojx, settings and files
target N32G457QEL7 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G452CCL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.5
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: V2205屏幕_V +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32G45X, USE_STDPERIPH_DRIVER,USE_SPI_FLASH
  c misc: --c99 --no-multibyte-chars
  c include: ..\..\firmware\CMSIS\core;..\..\firmware\CMSIS\device;..\..\firmware\n32g45x_std_periph_driver\inc;..\..\firmware\n32g45x_usbfs_driver;..\..\firmware\n32g45x_usbfs_driver\inc;..\Driver\inc;..\LCD_GUI;..\FatFS\inc;..\zhuimi
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../firmware/CMSIS/device/startup/: startup_n32g45x.s
  group CMSIS
    ../../firmware/CMSIS/device/: system_n32g45x.c
  group FWLB
    ../../firmware/n32g45x_std_periph_driver/src/: misc.c n32g45x_adc.c n32g45x_bkp.c n32g45x_can.c n32g45x_comp.c n32g45x_crc.c n32g45x_dac.c n32g45x_dbg.c n32g45x_dma.c n32g45x_dvp.c n32g45x_eth.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_i2c.c n32g45x_iwdg.c n32g45x_opamp.c n32g45x_pwr.c n32g45x_qspi.c n32g45x_rcc.c n32g45x_rtc.c n32g45x_sdio.c n32g45x_spi.c n32g45x_tim.c n32g45x_tsc.c n32g45x_usart.c n32g45x_wwdg.c n32g45x_xfmc.c
  group Driver
    ../Driver/src/: delay.c spi_flash.c bsp_usart.c spi_lcd.c bsp_pwm.c lcd_driver.c bsp_time.c bsp_interrupt.c bsp_rtc.c flash_access.c bsp_bkp.c dsp_led.c bsp_IdleIO.c bsp_Dma.c bsp_iwdog.c bsp_pvd.c
  group User
    ../: main.c
    C:/Users/admin/Desktop/: 2.c
  group zhuimi
    ../zhuimi/: Decode_Config.h Decode_Port.cpp DecodeLocate.cpp Decode.cpp Decode_Memory.cpp DecodeFont.cpp DecodeSingleText.cpp DecodeMultiLineText.cpp Draw.cpp StaticTextList.cpp
