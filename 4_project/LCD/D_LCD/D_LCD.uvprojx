# Keil uVision project D_LCD.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: N32G452CCL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.5
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: D_LCD +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: N32G45X, USE_STDPERIPH_DRIVER,USE_SPI_FLASH
  c include: .\_CODE;.\_CODE\BSP;.\_CODE\DEVICE;.\_CODE\FUNC;.\_CODE\LIB\n32g45x_std_periph_driver\inc;.\_CODE\LCD;.\_CODE\image
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group START
    ./_CODE/: startup_n32g45x.s
  group sys
    ./_CODE/: system_n32g45x.c
  group stdlib
    ./_CODE/LIB/n32g45x_std_periph_driver/src/: misc.c n32g45x_adc.c n32g45x_bkp.c n32g45x_can.c n32g45x_comp.c n32g45x_crc.c n32g45x_dac.c n32g45x_dbg.c n32g45x_dma.c n32g45x_dvp.c n32g45x_eth.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_i2c.c n32g45x_iwdg.c n32g45x_opamp.c n32g45x_pwr.c n32g45x_qspi.c n32g45x_rcc.c n32g45x_rtc.c n32g45x_sdio.c n32g45x_spi.c n32g45x_tim.c n32g45x_tsc.c n32g45x_usart.c n32g45x_wwdg.c n32g45x_xfmc.c
  group bsp
    ./_CODE/BSP/: delay.c bsp_time.c bsp_spix.c bsp_usart.c bsp_interrupt.c bsp_rtc.c bsp_bkp.c bsp_Dma.c bsp_iwdog.c bsp_pvd.c bsp_gpio.c
  group device
    ./_CODE/BSP/: spi_lcd.c spi_flash.c flash_access.c lcd_driver.c
  group func
    ./_CODE/FUNC/: lcdfunc.c
  group main
    ./_CODE/: config.c main.c config.h
  group LCD
    ./_CODE/image/: image0.c image1.c image3.c
software components: CMSIS:CORE 5.6.0
