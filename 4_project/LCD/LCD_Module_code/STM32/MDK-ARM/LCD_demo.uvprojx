# Keil uVision project LCD_demo.uvprojx, settings and files
target LCD_demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LCD_demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\User;..\User\GUI_DEV;..\User\Fonts;..\User\image;..\User\LCD;..\User\Config;..\User\example
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c gpio.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Gui
    ../User/GUI_DEV/: GUI_Paint.c
  group Fonts
    ../User/Fonts/: font8.c font12.c font12CN.c font16.c font20.c font24.c font24CN.c
  group Image
    ../User/image/: image.c
  group Config
    ../User/Config/: DEV_Config.c
  group Lcd_Drivers
    ../User/LCD/: LCD_0in96.c LCD_1in14.c LCD_1inch28.c LCD_1in3.c LCD_1in47.c LCD_1in54.c LCD_1in69.c LCD_1in8.c LCD_1in9.c LCD_2inch.c LCD_2inch4.c
  group Lcd_demo
    ../User/example/: LCD_0inch96_test.c LCD_1inch14_test.c LCD_1inch28_test.c LCD_1inch3_test.c LCD_1inch47_test.c LCD_1inch54_test.c LCD_1inch69_test.c LCD_1inch8_test.c LCD_1inch9_test.c LCD_2inch_test.c LCD_2inch4_test.c
software components: CMSIS:CORE 4.3.0
