# Keil uVision project ES32F0283.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ES32F0283LT Eastsoft
  pack: Eastsoft.ES32_DFP.1.0.11
  cpu: IRAM(0x20000000,0x00002000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: VY2308_ES +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\_0sys;.\_1library\LIB_MD\Include;.\_2bsp;.\_3device;.\_4func;.\_1library\LIB_REG;.\_0sys\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group start
    ./_0sys/: startup_es32f0283.s
  group system
    ./_0sys/: system_es32f0283.c interrupt.c
  group library
    ./_1library/LIB_MD/Source/: md_adc.c md_dma.c md_gpio.c md_rcu.c md_tick.c md_uart.c md_wwdt.c md_fc.c
  group bsp
    ./_2bsp/: gpiox.c timerx.c uartx.c uartxBAT.c flashx.c
  group device
    ./_2bsp/: Bat.c
  group func
    ./: main.c config.c
    ./_2bsp/: config.h BSP2DEVICE.h jump.c
software components: CMSIS:CORE 5.6.0
