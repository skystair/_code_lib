# Keil uVision project stm32f103.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: .\_code;.\_code\STM32F1xx_HAL_Driver\Inc;.\_code\CORE;.\_code\bsp;.\_code\device;.\_code\func;.\_code\func\usb_hid;.\_code\func\usb_lib
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group start
    ./_code/CORE/: startup_stm32f103xb.s
  group core
    ./_code/CORE/: stm32f1xx_it.c system_stm32f1xx.c
  group lib
    ./_code/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c
  group func
    ./_code/func/usb_hid/: usbd_hid.c
    ./_code/func/usb_lib/: usbd_conf.c usbd_core.c usbd_ctlreq.c usbd_desc.c usbd_ioreq.c
    ./_code/func/: usbd.c
  group main
    ./_code/: main.c config.h
software components: CMSIS:CORE 5.6.0
