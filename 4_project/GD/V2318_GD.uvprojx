# Keil uVision project V2318_GD.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: GD32F330C8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.0.2
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: V2318_GD +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F330
  c include: .\_CODE;.\_CODE\GD32F3x0_standard_peripheral\Include;.\_CODE\BSP;.\_CODE\DEVICES;.\_CODE\FUNCTION;.\_CODE\RTT
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group start
    ./_CODE/: startup_gd32f3x0.s
  group LIB
    ./_CODE/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_fmc.c gd32f3x0_gpio.c gd32f3x0_misc.c gd32f3x0_rcu.c gd32f3x0_timer.c gd32f3x0_usart.c gd32f3x0_syscfg.c gd32f3x0_exti.c gd32f3x0_dma.c gd32f3x0_fwdgt.c
  group BSP
    ./_CODE/BSP/: gpiox.c exitx.c adcx.c timerx.c uartx.c
    ./_CODE/FUNCTION/: flashdatafunc.c
  group DEVICES
    ./_CODE/DEVICES/: key.c LED.c trigger.c
  group FUNC
    ./_CODE/FUNCTION/: adhandle.c BatCap.c MainFunc.c Dust.c Dust_Analog.c Dust_Caculate.c
    ./_CODE/: Voice.c
  group MAIN
    ./_CODE/: systick.c system_gd32f3x0.c gd32f3x0_it.c config.c main.c config.h BSP2DEVICE.h gd32f3x0_libopt.h
  group VER
    ./: changelist.txt
  group segger
    ./_CODE/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_printf.c SEGGER_RTT_Conf.h
software components: CMSIS:CORE 5.6.0
