# Keil uVision project lib.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: ES32F0283LT Eastsoft
  pack: Eastsoft.ES32_DFP.1.0.11
  cpu: IRAM(0x20000000,0x00002000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Dustfunc (library)
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=3
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: dustfunc.c dustfunc.h
