# Keil uVision project ov9655d.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407VG
  c flags: Optim=7 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: .\_code;.\_code\LIB\inc;.\_code\bsp;.\_code\device;..\ov9655_D;.\_code\func
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group start
    ./: startup_stm32f4xx.s
  group system
    ./_code/: system_stm32f4xx.c stm32f4xx_it.c stm32f4xx_conf.h system_stm32f4xx.h User_systick.c
  group lib
    ./_code/LIB/src/: misc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_spi.c
  group bsp
    ./_code/bsp/: gpiox.c timerx.c uartx.c
  group device
    ./_code/device/: LCD_Driver.c LCD_lib.c dcmi_OV9655.c SCCB.C
  group func
    ./_code/func/: uart3func.c
  group Source Group 1
    ./: main.c
    ./_code/: config.h config.c
software components: CMSIS:CORE 5.6.0
